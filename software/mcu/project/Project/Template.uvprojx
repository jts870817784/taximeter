# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\Library\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\Library\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Library\CMSIS\CM3\CoreSupport;..\Library\STM32F10x_StdPeriph_Driver\inc;..\..\driver\Bluetooth;..\..\driver\delay;..\..\driver\EEPROM;..\..\driver\Key;..\..\driver\LCD12864;..\..\driver\LED;..\..\driver\MPU6050;..\..\driver\Realtime;..\..\driver\sys;..\..\driver\Timer;..\Source;..\..\driver\triger;..\Library\CMSIS\CM3\DeviceSupport\ST\STM32F10x
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group entry
    ../../framwork/entry/: main.c fram.c
  group CMSIS
    ../Library/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Library/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../Library/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group STM32_StdPeriph
    ../Library/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Bluetooth
    ../../driver/Bluetooth/: bsp_usart.c
  group delay
    ../../driver/delay/: delay.c
  group EEPROM
    ../../driver/EEPROM/: 24cxx.c
  group Key
    ../../driver/Key/: key.c
  group LCD12864
    ../../driver/LCD12864/: fonts.c lcd12864.c
  group LED
    ../../driver/LED/: led.c
  group MPU6050
    ../../driver/MPU6050/: bsp_i2c.c mpu6050.c
  group Realtime
    ../../driver/Realtime/: DS1307.c myiic.c
  group sys
    ../../driver/sys/: sys.c
  group Timer
    ../../driver/Timer/: bsp_TiMbase.c
  group Source
    ../Source/: stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group Triger
    ../../driver/triger/: timer_triger.c
